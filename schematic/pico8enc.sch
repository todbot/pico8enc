File: schematic/pico8enc.sch (EAGLE design)
At the start: 10 parts, among them U1 RASPBERRY_PICOSMD-TH

Commit message: pcb cleanup
Parts:
- renumbered U1 to PICO
